# Keil uVision project puppy-rtos.uvprojx, settings and files
target puppy-rtos (6180000::V6.18::ARMCLANG)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: puppy-rtos +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F412Zx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\..\kernel\include;..\..\nr_micro_shell\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: ..\link.sct
  group Application
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c borad.c
  group Library
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c system_stm32f4xx.c
    ../Drivers/CMSIS/Device/ST/STM32F4xx/arm/: startup_stm32f412zx.s
  group Kernel
    ../../kernel/src/: errno.c init.c irq.c object.c ostick.c sched.c sem.c syscall.c thread.c util.c
  group Arch
    ../../kernel/arch/arm/cortex-m4/: arch_thread.c arch_atomic.c arch_irq.c arch_syscall.c arch_syscall_helper.c
  group Tests
    ../../kernel-tests/: kapi_tc.c kobj_tc.c ktype_tc.c ksem_tc.c
  group cli
    ../../nr_micro_shell/src/: ansi.c ansi_port.c nr_micro_shell.c
    ../../nr_micro_shell/examples/: nr_micro_shell_commands.c
